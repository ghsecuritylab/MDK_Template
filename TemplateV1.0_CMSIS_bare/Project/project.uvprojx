# Keil uVision project project.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\RTE;.\RTE\Device\STM32F103RB;..\Applications;..\Docs;..\Drivers\board_drivers;..\Drivers\user_drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ../Applications/: main.c stm32f10x_it.c
  group Drivers/User
    ../Drivers/user_drivers/: digitron.c key.c led.c
  group Drivers/Board
    ../Drivers/board_drivers/: delay.c exti_dup.c rcc_config.c
  group Docs
    ../Docs/: readme.txt update_log.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
