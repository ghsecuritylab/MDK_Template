# Keil uVision project project.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10x_MD,USE_STDPERIPH_DRIVER
  c include: ..\Applications;..\Docs;..\Drivers\board_drivers;..\Drivers\user_drivers;..\STM32F10x_FWLib\Core\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\STM32F10x_FWLib\Core\CM3\CoreSupport;..\STM32F10x_FWLib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core/Startup
    ../STM32F10x_FWLib/Core/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_FWLib/Core/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers/Firmware_Lib
    ../STM32F10x_FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Application/User
    ../Applications/: main.c stm32f10x_it.c system_stm32f10x.c
  group Drivers/User
    ../Drivers/user_drivers/: digitron.c key.c led.c
  group Drivers/Board
    ../Drivers/board_drivers/: delay.c exti_dup.c rcc_config.c nvic_config.c tim_dup.c
  group Docs
    ../Docs/: readme.txt update_log.txt
