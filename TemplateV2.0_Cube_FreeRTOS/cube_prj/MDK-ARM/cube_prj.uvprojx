# Keil uVision project cube_prj.uvprojx, settings and files
target cube_prj (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cube_prj +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ..\..\STemWinLibrary522\Config; ..\..\STemWinLibrary522\OS; ..\..\STemWinLibrary522\inc; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ..\..\applications; ..\..\drivers\board_drivers; ..\..\drivers\user_drivers
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c
  group Drivers/Board
    ../../drivers/board_drivers/: delay.c exti_dup.c tim_dup.c bsp.c uart_dup.c
  group Drivers/User
    ../../drivers/user_drivers/: key.c lcd_ssd1289.c led.c
  group Application/User
    ../Src/: gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c main.c crc.c freertos.c stm32f1xx_hal_timebase_TIM.c dma.c usart.c
    ../../applications/: app_led.c
  group STemwin/Config
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/OS/: GUI_X.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c list.c timers.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Docs
    ../../docs/: readme.txt update_log.txt
software components: CMSIS:CORE 4.1.0
